### uVision2 Project, (C) Keil Software
### Do not modify !

Target (TEST), 0x0004 // Tools: 'ARM-ADS'

Group (StartUp)
Group (CMSIS)
Group (USB)
Group (SPL)
Group (Source Files)

File 1,2,<.\main\start_mdk\startup_stm32f10x_md.s><startup_stm32f10x_md.s>
File 2,5,<.\cmsis_mdk\stm32f10x.h><stm32f10x.h>
File 2,5,<.\spl\inc_mdk\stm32f10x_conf.h><stm32f10x_conf.h>
File 2,1,<.\cmsis_mdk\core_cm3.c><core_cm3.c>
File 2,1,<.\cmsis_mdk\system_stm32f10x.c><system_stm32f10x.c>
File 3,1,<.\usb\src\hw_config.c><hw_config.c>
File 3,1,<.\usb\src\usb_pwr.c><usb_pwr.c>
File 3,1,<.\usb\src\stm32_it.c><stm32_it.c>
File 3,1,<.\usb\src\usb_prop.c><usb_prop.c>
File 3,1,<.\usb\src\usb_istr.c><usb_istr.c>
File 3,1,<.\usb\src\usb_desc.c><usb_desc.c>
File 3,1,<.\usb\usb_fs\src\usb_core.c><usb_core.c>
File 3,1,<.\usb\usb_fs\src\usb_init.c><usb_init.c>
File 3,1,<.\usb\usb_fs\src\usb_int.c><usb_int.c>
File 3,1,<.\usb\usb_fs\src\usb_mem.c><usb_mem.c>
File 3,1,<.\usb\usb_fs\src\usb_regs.c><usb_regs.c>
File 3,1,<.\usb\usb_fs\src\usb_sil.c><usb_sil.c>
File 4,1,<.\spl\src\stm32f10x_rcc.c><stm32f10x_rcc.c>
File 5,1,<.\main\main.c><main.c>
File 5,1,<.\spl\src\stm32f10x_gpio.c><stm32f10x_gpio.c>
File 5,1,<.\spl\src\stm32f10x_usart.c><stm32f10x_usart.c>
File 5,1,<.\spl\src\misc.c><misc.c>
File 5,1,<.\spl\src\stm32f10x_tim.c><stm32f10x_tim.c>
File 5,1,<.\spl\src\stm32f10x_spi.c><stm32f10x_spi.c>
File 5,1,<.\spl\src\stm32f10x_iwdg.c><stm32f10x_iwdg.c>
File 5,1,<.\spl\src\stm32f10x_exti.c><stm32f10x_exti.c>
File 5,1,<.\spl\src\stm32f10x_adc.c><stm32f10x_adc.c>
File 5,1,<.\spl\src\stm32f10x_dac.c><stm32f10x_dac.c>
File 5,1,<.\spl\src\stm32f10x_i2c.c><stm32f10x_i2c.c>
File 5,1,<.\spl\src\stm32f10x_dma.c><stm32f10x_dma.c>
File 5,1,<.\spl\src\stm32f10x_flash.c><stm32f10x_flash.c>


Options 1,0,0  // Target 'TEST'
 Device (STM32F103C8)
 Vendor (STMicroelectronics)
 Cpu (IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3"))
 FlashUt ()
 StupF ("STARTUP\ST\STM32F10x\startup_stm32f10x_md.s" ("STM32 Medium Density Line Startup Code"))
 FlashDR (UL2CM3(-O14 -S0 -C0 -N00("ARM Cortex-M3") -D00(1BA00477) -L00(4) -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL010000))
 DevID (4235)
 Rgf (stm32f10x.h)
 Mem ()
 C ()
 A ()
 RL ()
 OH ()
 DBC_IFX ()
 DBC_CMS ()
 DBC_AMS ()
 DBC_LMS ()
 UseEnv=0
 EnvBin ()
 EnvInc ()
 EnvLib ()
 EnvReg (ST\STM32F10x\)
 OrgReg (ST\STM32F10x\)
 TgStat=16
 OutDir (.\bin\)
 OutName (..\test)
 GenApp=1
 GenLib=0
 GenHex=0
 Debug=0
 Browse=0
 LstDir (.\lst\)
 HexSel=1
 MG32K=0
 TGMORE=0
 RunUsr 0 0 <>
 RunUsr 1 0 <>
 BrunUsr 0 0 <>
 BrunUsr 1 0 <>
 CrunUsr 0 0 <>
 CrunUsr 1 0 <>
 SVCSID <>
 GLFLAGS=1790
 ADSFLGA { 226,31,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ACPUTYP ("Cortex-M3")
 RVDEV ()
 ADSTFLGA { 0,12,0,2,99,0,0,66,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSOCM { 0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 OCMADSIRAM { 0,0,0,0,32,0,80,0,0 }
 OCMADSIROM { 1,0,0,0,8,0,0,1,0 }
 OCMADSXRAM { 0,0,0,0,0,0,0,0,0 }
 OCR_RVCT { 1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,0,0,0,0,0,1,0,0,0,8,0,0,1,0,1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,32,0,80,0,0,0,0,0,0,0,0,0,0,0 }
 RV_STAVEC ()
 ADSCCFLG { 5,34,0,4,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSCMISC ()
 ADSCDEFN (USE_STDPERIPH_DRIVER STM32F10X_MD)
 ADSCUDEF ()
 ADSCINCD (.\cmsis_mdk;.\spl\inc_mdk;.\spl\inc;.\spl\src;.\main;.\usb\inc;.\usb\src;.\usb\usb_fs\inc;.\usb\usb_fs\src)
 ADSASFLG { 1,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSAMISC ()
 ADSADEFN ()
 ADSAUDEF ()
 ADSAINCD ()
 PropFld { 0,128,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 IncBld=1
 AlwaysBuild=0
 GenAsm=0
 AsmAsm=0
 PublicsOnly=0
 StopCode=3
 CustArgs ()
 LibMods ()
 ADSLDFG { 17,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0,0 }
 ADSLDTA (0x08000000)
 ADSLDDA (0x20000000)
 ADSLDSC ()
 ADSLDIB ()
 ADSLDIC ()
 ADSLDMC ()
 ADSLDIF ()
 ADSLDDW ()
  OPTDL (SARMCM3.DLL)()(DARMSTM.DLL)(-pSTM32F103C8)(SARMCM3.DLL)()(TARMSTM.DLL)(-pSTM32F103C8)
  OPTDBG 311294,12,()()()()()()()()()() (STLink\ST-LINKIII-KEIL_SWO.dll)()()()
 FLASH1 { 25,0,0,0,1,0,0,0,0,16,0,0,0,0,0,0,0,0,0,0 }
 FLASH2 (BIN\UL2CM3.DLL)
 FLASH3 ()
 FLASH4 ()
EndOpt
