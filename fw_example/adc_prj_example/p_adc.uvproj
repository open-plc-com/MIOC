# Keil uVision project p_adc.uvproj, settings and files
target P_ADC (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ..\p_adc
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F10X_MD
  c include: .\cmsis_mdk;.\spl\inc_mdk;.\spl\inc;.\spl\src;.\main;.\usb\inc;.\usb\src;.\usb\usb_fs\inc;.\usb\usb_fs\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./main/start_mdk/: startup_stm32f10x_md.s
  group CMSIS
    ./cmsis_mdk/: stm32f10x.h core_cm3.c system_stm32f10x.c
    ./spl/inc_mdk/: stm32f10x_conf.h
  group USB
    ./usb/src/: hw_config.c usb_pwr.c stm32_it.c usb_prop.c usb_istr.c usb_desc.c
    ./usb/usb_fs/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group SPL
    ./spl/src/: stm32f10x_rcc.c
  group Source Files
    ./main/: main.c
    ./spl/src/: stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_i2c.c stm32f10x_dma.c stm32f10x_flash.c
